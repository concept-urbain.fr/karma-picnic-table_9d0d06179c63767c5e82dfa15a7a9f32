Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma Table de pique-nique.IFC
Time: 2020-07-01T07:37:14
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: KARM-BANQ-004_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANQ-003_Default (2)
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-TABLE-003_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 66.986; Area Measure: 3.80232; Volume Measure: 0.0293009

# IfcBuildingElementProxy: KARM-TABLE-006_Default (2)
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-TABLE-007_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-TABLE-009_Default (2)
In: Default Storey
Material: S 235
